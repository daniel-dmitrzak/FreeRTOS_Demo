# IAR project Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; RVDS_ARMCM3_LM3S102; STM32303C_EVAL; USB_INT_DEFAULT; __TARGET_FPU_VFP; USE_STM32303C_EVAL
  ICCARM.CCDiagSuppress: Pe188, Pa082, Pe550
  ICCARM.PreInclude: stm32f30x.h
  ICCARM.CCIncludePath2: ..\Source\portable\RVDS\ARM_CM4F; ..\Source\include; ..\Demo\Utilities\STM32F3_Discovery; ..\Demo\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\Demo; ..\Demo\Libraries\CMSIS\Include; ..\Demo\Libraries\CMSIS\Device\ST\STM32F30x\Include; ..\Demo\Virtual_COM_USB\inc; ..\Demo\Virtual_COM_User\inc; ..\Demo\Utilities\STM32303C_EVAL; ..\Demo\Utilities\Common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..\Source\portable\RVDS\ARM_CM4F; ..\Source\include; ..\Demo\Utilities\STM32F3_Discovery; ..\Demo\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\Demo; ..\Demo\Libraries\CMSIS\Include; ..\Demo\Libraries\CMSIS\Device\ST\STM32F30x\Include; ..\Demo\Virtual_COM_USB\inc; ..\Demo\Virtual_COM_User\inc; ..\Demo\Utilities\STM32303C_EVAL; ..\Demo\Utilities\Common
  OBJCOPY.OOCOutputFile: Demo.bin
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group EWARM
    ./: startup_stm32f30x.s
  group FreeRTOS
    ../Source/: croutine.c list.c queue.c tasks.c timers.c
    ../Source/portable/MemMang/: heap_2.c
    ../Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group STM32F3-Discovery
    ../Demo/Utilities/STM32F3_Discovery/: stm32f3_discovery.c
  group STM32F30x_StdPeriph_Driver
    ../Demo/Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
  group User
    ../Demo/: main.c stm32f30x_it.c
  group Virtual COM USB
    ../Demo/Virtual_COM_USB/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Virtual COM User
    ../Demo/Virtual_COM_User/src/: hw_config.c system_stm32f30x.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
